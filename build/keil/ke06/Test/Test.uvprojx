# Keil uVision project Test.uvprojx, settings and files
target KE06Z-Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Test_Flash +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: KEIL FRDM_KE06 CPU_KE06 CMSIS
  c include: ..\..\..\..\src\projects\ke06\Test;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\acmp;..\..\..\..\src\platforms;..\..;..\..\..\..\src\drivers\ics;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\wdog;..\..\..\..\src\drivers\ftm;..\..\..\..\src\drivers\nvm;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\kbi;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\crc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\iic;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\PMC;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\pwt;..\..\..\..\src\drivers\bitband;C:\Keil_v5\ARM\ARMCC\include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;C:\Users\Administrator.USER-20190222AX\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Core\Include;C:\Users\Administrator.USER-20190222AX\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\src\drivers\can
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group common
    ../../../../src/common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../../src/cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c
    ./: crto.s
  group drivers
    ../../../../src/drivers/gpio/: gpio.c
    ../../../../src/drivers/uart/: uart.c
    ../../../../src/drivers/wdog/: wdog.c
    ../../../../src/drivers/sim/: sim.c
    ../../../../src/drivers/rtc/: rtc.c
    ../../../../src/drivers/ics/: ics.c
    ../../../../src/drivers/acmp/: acmp.c
    ../../../../src/drivers/adc/: adc.c
    ../../../../src/drivers/can/: mscan.c
    ../../../../src/drivers/crc/: crc.c
    ../../../../src/drivers/ftm/: ftm.c
    ../../../../src/drivers/iic/: i2c.c
    ../../../../src/drivers/kbi/: kbi.c
    ../../../../src/drivers/nvm/: flash.c
    ../../../../src/drivers/pit/: pit.c
    ../../../../src/drivers/PMC/: pmc.c
    ../../../../src/drivers/pwt/: pwt.c
    ../../../../src/drivers/spi/: spi.c
  group platforms
    ../../../../src/platforms/: ke06_config.h
  group project
    ../../../../src/projects/KE06/Test/: Test.c isr.h
  group App
    ../../../../src/projects/KE06/Test/app/: System.c Tick.c
